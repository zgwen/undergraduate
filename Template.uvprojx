# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 工程模板 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\user;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Libraries\CMSIS\CM3\CoreSupport;.\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\APP\SysTick;.\APP\LED;.\APP\PWM;.\APP\printf;.\APP\IIC(24C02);.\APP\AT24Cxx;.\APP\DS18B20;.\APP\ADC;.\APP\RTC;.\APP\gui;.\APP\lcd;.\APP\DAC;.\APP\PWM_DAC;.\APP\DMA;.\APP\spi;.\APP\flash;.\APP\touch;.\APP\SRAM;.\APP\malloc;.\APP\sd;.\APP\adx345;.\APP\can;.\FATFS;.\APP\fatapp;.\APP\bmp;.\APP\key;.\APP\lowpower;.\APP\iwdg;.\APP\hwjs;.\APP\beep;.\APP\time;.\APP\SEG;.\APP\exti;.\APP\usart;.\APP\RS485;.\APP\IIC(24C02)
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user
    ./user/: main.c stm32f10x_it.c public.c
  group cmsis
    ./Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group startup
    ./startup/: startup_stm32f10x_hd.s
  group StdPeriph_Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_fsmc.c stm32f10x_dac.c stm32f10x_spi.c stm32f10x_flash.c stm32f10x_can.c stm32f10x_exti.c
  group APP
    ./APP/LED/: led.c
    ./APP/SysTick/: systick.c
    ./APP/RS485/: rs485.c
    ./APP/printf/: printf.c
    ./APP/IIC(24C02)/: iic.c
    ./APP/AT24Cxx/: AT24CXX.c
    ./APP/ADC/: adc.c
    ./APP/lcd/: lcd_driver.c
    ./APP/gui/: gui.c
    ./APP/DAC/: dac.c
    ./APP/spi/: spi.c
    ./APP/flash/: flash.c
    ./APP/touch/: touch.c
    ./APP/SRAM/: sram.c
    ./APP/malloc/: malloc.c
    ./APP/sd/: sd.c
    ./APP/DS18B20/: ds18b20.c
    ./APP/adx345/: adx345.c
    ./APP/can/: can.c
    ./APP/fatapp/: myFatApp.c
    ./APP/bmp/: bmp.c
    ./APP/beep/: beep.c
    ./APP/key/: key.c
    ./APP/usart/: usart.c
    ./APP/SEG/: smg.c
    ./APP/hwjs/: hwjs.c
    ./APP/lowpower/: lowpower.c
  group FATFS
    ./FATFS/: cc936.c diskio.c ff.c
software components: CMSIS:CORE 5.0.0
